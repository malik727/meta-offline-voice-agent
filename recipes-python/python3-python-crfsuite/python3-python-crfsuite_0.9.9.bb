SUMMARY = "A python binding for crfsuite"
HOMEPAGE = "https://github.com/scrapinghub/python-crfsuite"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=0a36d267a3ece77cbc8ebc95ca7e2edd"

PYPI_PACKAGE = "python-crfsuite"

SRC_URI[md5sum] = "01691860ad087f1270a78062ba0ded4c"
SRC_URI[sha256sum] = "caa6261d6955466756f986b7fcfbd4fd50622963e3bdb5cc180c129c62b3a76d"

inherit pypi setuptools3
