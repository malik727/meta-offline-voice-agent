SUMMARY = "Extended pickling support for Python objects"
HOMEPAGE = "https://github.com/cloudpipe/cloudpickle"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b4d59aa5e2cc777722aac17841237931"

PYPI_PACKAGE = "cloudpickle"

SRC_URI[md5sum] = "640430615bdb68e1900bc26b84fad967"
SRC_URI[sha256sum] = "d89684b8de9e34a2a43b3460fbca07d09d6e25ce858df4d5a44240403b6178f5"

inherit pypi setuptools3
