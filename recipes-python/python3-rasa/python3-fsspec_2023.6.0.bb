SUMMARY = "A specification that python filesystems should adhere to."
HOMEPAGE = "https://github.com/fsspec/filesystem_spec"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b38a11bf4dcdfc66307f8515ce1fbaa6"

PYPI_PACKAGE = "fsspec"

SRC_URI[md5sum] = "a6776f6c387e09c54146d7cc10e6c434"
SRC_URI[sha256sum] = "d0b2f935446169753e7a5c5c55681c54ea91996cc67be93c39a154fb3a2742af"

inherit pypi setuptools3
