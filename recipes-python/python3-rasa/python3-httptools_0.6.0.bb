SUMMARY = "Fast HTTP parser"
HOMEPAGE = "https://github.com/MagicStack/httptools"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=0a2d82955bf3facdf04cb882655e840e"

PYPI_PACKAGE = "httptools"

SRC_URI[md5sum] = "4e55dacfe4238afa94ba670f16c426a0"
SRC_URI[sha256sum] = "9fc6e409ad38cbd68b177cd5158fc4042c796b82ca88d99ec78f07bed6c6b796"

inherit pypi setuptools3
