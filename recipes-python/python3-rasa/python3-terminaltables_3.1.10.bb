SUMMARY = "Generate simple tables in terminals from a nested list of strings."
HOMEPAGE = "https://github.com/matthewdeanmartin/terminaltables"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5f85abc11673af717387593a5281f87a"

PYPI_PACKAGE = "terminaltables"

SRC_URI[md5sum] = "5467e06a1a6e24dc44e6dd241706668e"
SRC_URI[sha256sum] = "ba6eca5cb5ba02bba4c9f4f985af80c54ec3dccf94cfcd190154386255e47543"

inherit pypi setuptools3
