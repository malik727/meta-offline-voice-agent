SUMMARY = "Low level AMQP frame encoding and decoding library"
HOMEPAGE = "https://github.com/gmr/pamqp"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1b4ca9d54d51a18213e82da5f6bc9ecd"

PYPI_PACKAGE = "pamqp"

SRC_URI[md5sum] = "cccc4329b7a7910928d6fba7e5c5709c"
SRC_URI[sha256sum] = "22550ceb1ca50aafda65873e77e8c1c1b139fb5975e1a09860fae940cf8e970a"

inherit pypi setuptools3
