SUMMARY = "A functional standard library for Python."
HOMEPAGE = "https://github.com/pytoolz/toolz"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=ca09cab178326d18433aae982d1edf5d"

PYPI_PACKAGE = "toolz"

SRC_URI[md5sum] = "5ca1991596816c576b02237ab3d29f0c"
SRC_URI[sha256sum] = "88c570861c440ee3f2f6037c4654613228ff40c93a6c25e0eba70d17282c6194"

inherit pypi setuptools3
