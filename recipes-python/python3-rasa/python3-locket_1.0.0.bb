SUMMARY = "File-based locks for Python on Linux and Windows"
HOMEPAGE = "https://github.com/mwilliamson/locket.py"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=43656003bc006fb5bbd82fc1f313598e"

PYPI_PACKAGE = "locket"

SRC_URI[md5sum] = "fff6d2fcd92fbeb9af9dbc260eb0b5e8"
SRC_URI[sha256sum] = "5c0d4c052a8bbbf750e056a8e65ccd309086f4f0f18a2eac306a8dfa4112a632"

inherit pypi setuptools3
