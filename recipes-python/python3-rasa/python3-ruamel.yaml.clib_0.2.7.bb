SUMMARY = "C version of reader, parser and emitter for ruamel.yaml"
HOMEPAGE = "https://sourceforge.net/projects/ruamel-yaml-clib/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=835b7de93e6217192ffce476ecb74e86"

PYPI_PACKAGE = "ruamel.yaml.clib"

SRC_URI[md5sum] = "4b7bc49c0022baf161203dc1ea4806f9"
SRC_URI[sha256sum] = "1f08fd5a2bea9c4180db71678e850b995d2a5f4537be0e94557668cf0f5f9497"

inherit pypi setuptools3
