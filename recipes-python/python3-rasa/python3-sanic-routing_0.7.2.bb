SUMMARY = "nternal handler routing for Sanic beginning with v21.3."
HOMEPAGE = "https://github.com/sanic-org/sanic-routing/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=5beb17d8bb3a5e27e9eddc439ada4f13"

PYPI_PACKAGE = "sanic-routing"

SRC_URI[md5sum] = "f574de41733278fd3f77e10d039a2081"
SRC_URI[sha256sum] = "139ce88b3f054e7aa336e2ecc8459837092b103b275d3a97609a34092c55374d"

inherit pypi setuptools3
